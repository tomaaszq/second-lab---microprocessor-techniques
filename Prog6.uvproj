# Keil uVision project Prog6.uvproj, settings and files
target Lab6 (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Prog6
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Device
    ./Device/: startup_LPC11xx.s system_LPC11xx.c
  group Source
    ./Source/: 6_main_uzupelnic.c
  group Abstract
    ./: 6_Abstract.txt
